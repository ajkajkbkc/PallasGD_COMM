# Keil uVision project Pallas_GD.uvprojx, settings and files
target Pallas_GD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pallas_GD +hex
  AfterMake: ..\Binary\hex2bin.exe ..\MDK-ARM\Pallas_GD\Pallas_GD.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\PallasApp;..\PallasApp\DS18B20;..\PallasApp\FlexibleButton-v1.0.0;..\PallasApp\ModBus;..\PallasApp\IAP;..\PallasApp\Internet;..\PallasApp\CJSON;..\W5500\Ethernet;..\W5500\Ethernet\W5500;..\W5500\Internet\MQTT;..\W5500\Internet\MQTT\MQTTPacket\src;..\PallasApp\oled;..\dlt645
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../PallasApp/: kalyke_monitor_task.h
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group PallasApp
    ../PallasApp/: app_version.h app_opts.h app_main.c app_main.h app_log.c app_log.h app_tool.c app_tool.h app_uart.c app_uart.h app_parameter.c app_parameter.h app_led.c app_led.h app_rtc.c app_rtc.h app_ntc.c app_ntc.h app_payload.c app_payload.h app_att7022eu.c app_att7022eu.h app_oled.c app_oled.h kalyke_event.c kalyke_event.h kalyke_internet_task.h infra_defs.h plc_element.h kalyke_4G_task.c kalyke_4G_task.h bsp_dct.c bsp_dct.h plc_netcfg.c plc_netcfg.h plc_task.c plc_task.h plc_variable.h kalyke_cJSON.c kalyke_cJSON.h kalyke_monitor_task.h bsp_uart.h kalyke_monitor_task.c plc_element.c plc_variable.c module_ESE.c module_ESE.h app_collect.c app_collect.h NTP.c NTP.h app_tou.c app_tou.h
  group PallasApp/IAP
    ../PallasApp/IAP/: iap.c iap.h
  group PallasApp/FlexibleButton
    ../PallasApp/FlexibleButton-v1.0.0/: flexible_button.c flexible_button.h
  group PallasApp/ModBus
    ../PallasApp/ModBus/: mb.c mb.h mb_crc.c mb_crc.h mb_maptable.c mb_maptable.h
  group PallasApp/internet
    ../PallasApp/Internet/: internet.c internet.h mbtcp.c mbtcp.h mqtt.c mqtt.h hzudp.c hzudp.h lltudp.c lltudp.h
  group PallasApp/CJSON
    ../PallasApp/CJSON/: cJSON.c cJSON.h
  group W5500/Ethernet
    ../W5500/Ethernet/W5500/: w5500.c w5500.h
    ../W5500/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
  group W5500/Internet/MQTT
    ../W5500/Internet/MQTT/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h
  group W5500/Internet/MQTT/MQTTPacket
    ../W5500/Internet/MQTT/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group PallasApp/oled
    ../PallasApp/oled/: oled_codetab.c oled_codetab.h oled_i2c.c oled_i2c.h
  group dlt645
    ../dlt645/: dlt645_2007.c dlt645_2007.h
software components: CMSIS:CORE 5.6.0
